# Keil uVision project app.uvprojx, settings and files
target APP (6160000::V6.16::ARMCLANG)
  device: GD32L233RC GigaDevice
  pack: GigaDevice.GD32L23x_DFP.0.0.0
  cpu: IRAM(0x20000000,0x0008000) IROM(0x08000000,0x0040000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: app_v1 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=7 v6Lang=2 v6LangP=3 v6Lto=1 wLevel=3
  c misc: -Wno-invalid-source-encoding
  c include: ..\..\bsp-base;..\..\bsp-drv;..\..\CMSIS\Core\Include;..\..\bsp-lib;..\..\drv-user;..\..\user-app;..\..\..\bootloader_ymodem\drv-user;..\..\..\..\..\source\bootloader\Core
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0x40000
  memory RVCT9: RAM 0x20000008 size 0x7c00
  memory RVCT10: RAM 0x20000000 size 0x8
  group user_app
    ../../user-app/: main.c
    ../../bsp-base/: gd32l23x_it.c
  group bsp-drv
    ../../bsp-drv/: gd32l233r_eval.c gd32l233r_eval.h
  group bsp-lib
    ../../bsp-lib/: gd32l23x_exti.c gd32l23x_fmc.c gd32l23x_gpio.c gd32l23x_misc.c gd32l23x_rcu.c gd32l23x_spi.c gd32l23x_syscfg.c gd32l23x_usart.c
  group bsp-base
    ../../bsp-base/: system_gd32l23x.c systick.c startup_gd32l23x.s
