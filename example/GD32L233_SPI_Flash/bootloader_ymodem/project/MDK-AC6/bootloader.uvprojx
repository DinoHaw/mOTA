# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (6210000::V6.21::ARMCLANG)
  device: GD32L233RC GigaDevice
  pack: GigaDevice.GD32L23x_DFP.1.0.3
  cpu: IRAM(0x20000000,0x0008000) IROM(0x08000000,0x0040000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: bootloader +hex
  AfterMake: fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=7 v6Lang=4 v6LangP=3 v6Lto=1 wLevel=3
  c include: ..\..\bsp-base;..\..\bsp-lib;..\..\bsp-drv;..\..\drv-user;..\..\user-app;..\..\drv-component\FAL\config;..\..\drv-component\SFUD\config;..\..\drv-component\SEGGER_RTT\config;..\..\drv-user\Module;..\..\drv-user\User;..\..\drv-user\Bsp;..\..\..\..\..\source\bootloader\Core;..\..\..\..\..\source\bootloader\Component\crc-lib-c;..\..\..\..\..\source\bootloader\Component\FAL\inc;..\..\..\..\..\source\bootloader\Component\perf_counter;..\..\..\..\..\source\bootloader\Component\SEGGER_RTT\RTT;..\..\..\..\..\source\bootloader\Component\sfud\sfud\inc;..\..\..\..\..\source\bootloader\Component\tinyAES;..\..\..\..\..\source\BSP\inc;..\..\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8
  memory RVCT10: RAM 0x20000008 size 0x7ff8
  group user_app
    ../../user-app/: main.c
    ../../drv-user/User/: user.c
    ../../bsp-base/: gd32l23x_it.c
  group user_module
    ../../../../../source/bootloader/Core/: firmware_manage.c
    ../../drv-user/Module/: protocol_parser.c data_transfer.c data_transfer_port.c
  group bootloader
    ../../drv-user/: bootloader_config.h
    ../../../../../source/bootloader/Core/: bootloader.c
    ../../drv-user/User/: bootloader_port.c
  group bsp-base
    ../../bsp-base/: system_gd32l23x.c systick.c startup_gd32l23x.s
  group bsp-lib
    ../../bsp-lib/: gd32l23x_exti.c gd32l23x_fmc.c gd32l23x_gpio.c gd32l23x_spi.c gd32l23x_syscfg.c gd32l23x_usart.c gd32l23x_dma.c gd32l23x_misc.c gd32l23x_rcu.c
  group bsp-drv
    ../../drv-user/Bsp/: common.h bsp_common.h bsp_board.h bsp_board.c
    ../../bsp-drv/: bsp_config.h bsp_usart1_drv.c bsp_debug_drv.c bsp_flash_drv.c bsp_fmc_drv.c
  group bsp-user_drv
    ../../../../../source/BSP/src/: bsp_timer.c
    ../../drv-user/Bsp/: bsp_uart_drv_port.c
  group component-fal
    ../../drv-component/FAL/config/: fal_cfg.h
    ../../../../../source/bootloader/Component/FAL/src/: fal.c fal_flash.c fal_partition.c
    ../../../../../source/bootloader/Component/FAL/samples/porting/: fal_gd32l233_flash.c
    ../../drv-component/FAL/port/: fal_flash_sfud_port.c
  group component-sfud
    ../../drv-component/SFUD/config/: sfud_cfg.h
    ../../../../../source/bootloader/Component/sfud/sfud/inc/: sfud_flash_def.h
    ../../../../../source/bootloader/Component/sfud/sfud/src/: sfud.c sfud_sfdp.c
    ../../drv-component/SFUD/port/: sfud_port.c
  group component-tinyAES
    ../../../../../source/bootloader/Component/tinyAES/: aes.c
  group component-CRC_Lib
    ../../../../../source/bootloader/Component/crc-lib-c/: crcLib.c
  group component-perf_counter
    ../../../../../source/bootloader/Component/perf_counter/: perf_counter.c systick_wrapper_ual.s
  group component-SEGGER_RTT
    ../../drv-component/SEGGER_RTT/config/: SEGGER_RTT_Conf.h
    ../../../../../source/bootloader/Component/SEGGER_RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
