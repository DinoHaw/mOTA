# Keil uVision project STM32F1.uvprojx, settings and files
target debug (6160000::V6.16::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: app_v2 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: CopyHexBin.bat
  c flags: Optim=7 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\CubeMX\Inc;..\CubeMX/Drivers/STM32F1xx_HAL_Driver/Inc;..\CubeMX/Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;..\CubeMX/Drivers/CMSIS/Device/ST/STM32F1xx/Include;..\CubeMX/Drivers/CMSIS/Include;..\..\BSP\inc;..\..\APP\Module;..\..\APP\User;..\..\Config;..\..\Component\FAL\inc;..\..\Component\FAL\samples\porting;..\..\Component\sfud\inc;..\..\Component\sfud\port;..\..\Component\tinycrypt\lib\include;..\..\Component\tinycrypt\tests\include;..\..\Component\fastlz;..\..\Component\lwmem-develop\lwmem\src\include;..\..\Component\tinyAES;..\..\Component\SEGGER_RTT\RTT;..\..\Component\crc-lib-c-master
  asm define: APP_VERSION=0x00010001
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x80000
  memory RVCT9: RAM 0x20000008 size 0xfff8
  memory RVCT10: RAM 0x20000000 size 0x8
  group CubeMX
    ../CubeMX/Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group APP/User
    ../../APP/User/: app_config.h app.c
  group Drivers/BSP
    ../../BSP/inc/: bsp_config.h bsp_common.h
    ../../BSP/src/: bsp_gpio.c bsp_uart.c bsp_uart_port.c bsp_timer.c bsp_key.c
  group Component/SEGGER_RTT
    ../../Component/SEGGER_RTT/RTT/: SEGGER_RTT_Conf.h SEGGER_RTT.c SEGGER_RTT_printf.c
  group HAL/STM32F1
    ../CubeMX/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group HAL/CMSIS
    ../CubeMX/Src/: system_stm32f1xx.c
  group MDK-ARM
    ../CubeMX/MDK-ARM/: startup_stm32f103xe.s
