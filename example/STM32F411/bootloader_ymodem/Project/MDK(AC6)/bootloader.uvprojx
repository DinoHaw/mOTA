# Keil uVision project bootloader.uvprojx, settings and files
target debug (6190000::V6.19::ARMCLANG)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader_ymodem +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: CopyHexBin.bat
  c flags: Optim=7 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ..\CubeMX\Core\Inc;..\CubeMX/Drivers/STM32F4xx_HAL_Driver/Inc;..\CubeMX/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;..\CubeMX/Drivers/CMSIS/Device/ST/STM32F4xx/Include;..\CubeMX/Drivers/CMSIS/Include;..\..\BSP\inc;..\..\APP\Module;..\..\APP\User;..\..\Config;..\..\Component\FAL\inc;..\..\Component\FAL\samples\porting;..\..\Component\sfud\inc;..\..\Component\sfud\port;..\..\Component\tinycrypt\lib\include;..\..\Component\tinycrypt\tests\include;..\..\Component\fastlz;..\..\Component\lwmem-develop\lwmem\src\include;..\..\Component\tinyAES;..\..\Component\SEGGER_RTT\RTT;..\..\Component\crc-lib-c-master
  asm define: APP_VERSION=0x00010001
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000008 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x8
  group CubeMX
    ../CubeMX/Core/Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group APP/User
    ../../Config/: user_config.h
    ../../APP/User/: app_config.h app.c
  group APP/Module
    ../../APP/Module/: firmware_manage.c protocol_parser.c data_transfer.c data_transfer_port.c utils.c
  group Drivers/BSP
    ../../BSP/inc/: bsp_config.h bsp_common.h
    ../../BSP/src/: bsp_board.c bsp_uart.c bsp_uart_port.c bsp_timer.c bsp_flash.c bsp_key.c
  group Component/FAL
    ../../Component/FAL/src/: fal.c fal_flash.c fal_partition.c
    ../../Component/FAL/samples/porting/: fal_stm32f4_flash.c
  group Component/SFUD
    ../../Component/sfud/src/: sfud.c sfud_sfdp.c
    ../../Component/sfud/port/: sfud_port.c
  group Component/TinyAES
    ../../Component/tinyAES/: aes.c
  group Component/CRC_Lib
    ../../Component/crc-lib-c-master/: crcLib.c
  group Component/SEGGER_RTT
    ../../Component/SEGGER_RTT/RTT/: SEGGER_RTT_Conf.h SEGGER_RTT.c SEGGER_RTT_printf.c
  group HAL/STM32F4
    ../CubeMX/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group HAL/CMSIS
    ../CubeMX/Core/Src/: system_stm32f4xx.c
  group MDK-ARM
    ../CubeMX/MDK-ARM/: startup_stm32f411xe.s
    ../../Config/: no_semihosting.c
