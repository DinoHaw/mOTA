# Keil uVision project bootloader.uvprojx, settings and files
target debug (6210000::V6.21::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader_ymodem +hex
  AfterMake: after_build.bat
  c flags: Optim=7 oTime=1 OneElfS=1 uC99=1 v6Lang=4 v6LangP=5 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\CubeMX\Inc;..\CubeMX/Drivers/STM32F1xx_HAL_Driver/Inc;..\CubeMX/Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;..\CubeMX/Drivers/CMSIS/Device/ST/STM32F1xx/Include;..\CubeMX/Drivers/CMSIS/Include;..\..\BSP\inc;..\..\..\..\..\source\BSP\inc;..\..\APP\Module;..\..\APP\User;..\..\Config;..\..\..\..\..\source\bootloader\Core;..\..\..\..\..\source\bootloader\Component\FAL\inc;..\..\..\..\..\source\bootloader\Component\sfud\sfud\inc;..\..\..\..\..\source\bootloader\Component\tinyAES;..\..\..\..\..\source\bootloader\Component\perf_counter;..\..\..\..\..\source\bootloader\Component\SEGGER_RTT\RTT;..\..\..\..\..\source\bootloader\Component\crc-lib-c;..\..\Component\FAL\config;..\..\Component\SFUD\config;..\..\Component\SEGGER_RTT\config
  asm define: APP_VERSION=0x00010001
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000008 size 0xfff8
  memory RVCT10: RAM 0x20000000 size 0x8
  group CubeMX
    ../CubeMX/Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group APP/User
    ../../Config/: bootloader_config.h
    ../../APP/User/: user.c bootloader_port.c
    ../../../../../source/bootloader/Core/: bootloader.c
  group APP/Module
    ../../../../../source/bootloader/Core/: firmware_manage.c
    ../../APP/Module/: protocol_parser.c data_transfer.c data_transfer_port.c
  group Drivers/BSP
    ../../BSP/inc/: bsp_config.h bsp_common.h
    ../../BSP/src/: bsp_board.c
    ../../../../../source/BSP/src/: bsp_timer.c bsp_flash.c bsp_key.c bsp_uart.c bsp_uart_stm32.c bsp_gpio_stm32.c
  group Component/FAL
    ../../Component/FAL/config/: fal_cfg.h
    ../../../../../source/bootloader/Component/FAL/src/: fal.c fal_flash.c fal_partition.c
    ../../../../../source/bootloader/Component/FAL/samples/porting/: fal_stm32f1_flash.c
    ../../Component/FAL/port/: fal_flash_sfud_port.c
  group Component/SFUD
    ../../Component/SFUD/config/: sfud_cfg.h
    ../../../../../source/bootloader/Component/sfud/sfud/src/: sfud.c sfud_sfdp.c
    ../../Component/SFUD/port/: sfud_port.c
  group Component/TinyAES
    ../../../../../source/bootloader/Component/tinyAES/: aes.c
  group Component/CRC_Lib
    ../../../../../source/bootloader/Component/crc-lib-c/: crcLib.c
  group Component/perf_counter
    ../../../../../source/bootloader/Component/perf_counter/: perf_counter.c systick_wrapper_ual.s
  group Component/SEGGER_RTT
    ../../Component/SEGGER_RTT/config/: SEGGER_RTT_Conf.h
    ../../../../../source/bootloader/Component/SEGGER_RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group HAL/STM32F1
    ../CubeMX/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_spi.c
  group HAL/CMSIS
    ../CubeMX/Src/: system_stm32f1xx.c
  group MDK-ARM
    ../CubeMX/MDK-ARM/: startup_stm32f103xe.s
