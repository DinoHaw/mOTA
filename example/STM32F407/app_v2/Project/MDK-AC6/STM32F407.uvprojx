# Keil uVision project STM32F407.uvprojx, settings and files
target debug (6210000::V6.21::ARMCLANG)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: app_v2 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: after_build.bat
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=4 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\CubeMX\Core\Inc;..\CubeMX\Drivers\STM32F4xx_HAL_Driver\Inc;..\CubeMX\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\CubeMX\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\CubeMX/Drivers/CMSIS/Include;..\..\BSP\inc;..\..\APP\Module;..\..\APP\User;..\..\Config;..\..\Component\SEGGER_RTT\config;..\..\..\bootloader_ymodem\Config;..\..\..\..\..\source\BSP\inc;..\..\..\..\..\source\bootloader\Core;..\..\..\..\..\source\bootloader\Component\SEGGER_RTT\RTT;..\..\..\..\..\source\bootloader\Component\perf_counter
  asm define: APP_VERSION=0x00010001
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x78000
  memory RVCT9: RAM 0x20000000 size 0x8
  memory RVCT10: RAM 0x20000008 size 0xfff8
  group CubeMX
    ../CubeMX/Core/Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group APP/User
    ../../../bootloader_ymodem/Config/: bootloader_config.h
    ../../APP/User/: app_config.h app.c
  group Drivers/BSP
    ../../BSP/inc/: bsp_config.h bsp_common.h
    ../../../../../source/BSP/src/: bsp_key.c bsp_timer.c bsp_uart.c bsp_uart_stm32.c bsp_gpio_stm32.c
  group Component/SEGGER_RTT
    ../../Component/SEGGER_RTT/config/: SEGGER_RTT_Conf.h
    ../../../../../source/bootloader/Component/SEGGER_RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group HAL/STM32F4
    ../CubeMX/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group HAL/CMSIS
    ../CubeMX/Core/Src/: system_stm32f4xx.c
  group MDK-ARM
    ../CubeMX/MDK-ARM/: startup_stm32f407xx.s
